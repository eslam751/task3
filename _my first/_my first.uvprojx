# Keil uVision project _my first.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: _my first
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\class1\Sprints_ARM\Src\Common;.\class1\Sprints_ARM\Src\Config;.\class1\Sprints_ARM\Src\Mcal\Inc;.\class1\Sprints_ARM\Src\Common
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Mcal
    ./class1/Sprints_ARM/Src/Mcal/: IntCtrl.c
  group AppI
    ./class1/Sprints_ARM/Src/Appl/: main.c
  group Config
    ./class1/Sprints_ARM/Src/Config/: IntCtrl_Lcfg.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.1
